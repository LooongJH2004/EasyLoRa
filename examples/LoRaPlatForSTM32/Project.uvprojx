# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --no-multibyte-chars
  c include: .\Start;.\Library;.\User;.\System;.\Hardware;.\function;.\Model;.\LoRa_Plat;.\LoRa_Plat\0_OSAL;.\LoRa_Plat\0_Utils;.\LoRa_Plat\1_Port;.\LoRa_Plat\2_Driver;.\LoRa_Plat\3_Manager;.\LoRa_Plat\4_Service
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/: startup_stm32f10x_md.s core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Library
    ./Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group System
    ./System/: Delay.c Delay.h
  group Hardware
    ./Hardware/: LED.c LED.h Key.c Key.h OLED.c OLED.h OLED_Font.h Serial.c Serial.h Timer.c Timer.h Flash.c Flash.h
  group User
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h lora_demo_osal.c
  group function
    ./function/: cJSON.c cJSON.h InputParser.c InputParser.h
  group Model
    ./Model/: Model.c Model.h Algorithm.c Algorithm.h Indicator.c Indicator.h
  group LoRa_Plat
    ./LoRa_Plat/: LoRaPlatConfig.h
    ./LoRa_Plat/0_OSAL/: lora_osal.c lora_osal.h
    ./LoRa_Plat/0_Utils/: lora_crc16.c lora_crc16.h lora_ring_buffer.c lora_ring_buffer.h
    ./LoRa_Plat/1_Port/: lora_port_stm32f10x.c lora_port.h
    ./LoRa_Plat/2_Driver/: lora_driver.c lora_driver.h lora_at_command_engine.c lora_at_command_engine.h lora_driver_ops.h driver_atk_lora01.c driver_ebyte_e32.c
    ./LoRa_Plat/3_Manager/: lora_manager.c lora_manager.h lora_manager_buffer.c lora_manager_buffer.h lora_manager_protocol.c lora_manager_protocol.h lora_manager_fsm.c lora_manager_fsm.h
    ./LoRa_Plat/4_Service/: lora_service.c lora_service.h lora_service_config.c lora_service_config.h lora_service_command.c lora_service_command.h lora_service_monitor.c lora_service_monitor.h
